FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}/${DISTRO}:"
