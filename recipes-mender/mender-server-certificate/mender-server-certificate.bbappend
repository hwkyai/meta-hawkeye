do_install_prepend() {
    cp "${MENDER_SERVER_CERT}" .
}
